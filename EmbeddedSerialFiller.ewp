# IAR project EmbeddedSerialFiller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx5A NXP MIMXRT1064xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: OS_DEBUG=1; __STDC_LIMIT_MACROS; PROFILE_IAR_ARM; PROFILE_EMBOS
  ICCARM.CCIncludePath2: etl\include; include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  prebuild: Beautifier.bat "$PROJ_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __STDC_LIMIT_MACROS; PROFILE_ARM_V6_GENERIC; PROFILE_EMBOS
  ICCARM.CCIncludePath2: include; etl\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Include
    include/: armv6.h esf_abstraction.h esf_embos_abstraction.h etl_profile.h
  group Include/EmbeddedSerialFiller
    include/EmbeddedSerialFiller/: CobsTranscoder.h Definitions.h EmbeddedSerialFiller.h Logger.h Utilities.h
  group Source
    src/: CobsTranscoder.cpp EmbeddedSerialFiller.cpp esf_embos_abstraction.cpp Utilities.cpp
